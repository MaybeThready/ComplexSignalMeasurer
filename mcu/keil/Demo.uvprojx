# Keil uVision project Demo.uvprojx, settings and files
target Demo (6240000::V6.24::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Demo +hex
  BeforeMake: cmd.exe /C "D:/Software/TI/MSPM0SDK/mspm0_sdk_2_08_00_03/tools/keil/syscfg.bat '$P' project.syscfg"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c misc: -ffast-math
  c include: D:\Software\TI\MSPM0SDK\mspm0_sdk_2_08_00_03\source;D:\Software\TI\MSPM0SDK\mspm0_sdk_2_08_00_03\source\third_party\CMSIS\Core\Include;D:\Software\TI\MSPM0SDK\mspm0_sdk_2_08_00_03\source\third_party\CMSIS\DSP\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: ./mspm0g3519.sct
  link misc: D:\Software\TI\MSPM0SDK\mspm0_sdk_2_08_00_03/source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a
D:\Software\TI\MSPM0SDK\mspm0_sdk_2_08_00_03\source\third_party\CMSIS\DSP\lib\keil\m0p\arm_cortexM0l_math.a
  group Source
    ./: startup_mspm0g351x_uvision.s
    ../: ti_msp_dl_config.h ti_msp_dl_config.c main.c project.syscfg ui_config.h ui_config.c signal.c signal.h tjc.c tjc.h
  group BSP
    ../bsp/: keyboard.c keyboard.h uart.c uart.h flash.c flash.h msp_sys.c msp_sys.h led.c led.h
    ../bsp/oled/: oled.c oled.h oled_driver.c oled_driver.h oled_fonts.c oled_fonts.h
  group UI
    ../ui/: ui.c ui.h
